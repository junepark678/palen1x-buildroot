## package/usbmuxd/Config.in
```kconfig
config BR2_PACKAGE_USBMUXD
      bool "usbmuxd"
      help
        usbmuxd is a server for connecting to iPhone/iPod Touch devices.
```
